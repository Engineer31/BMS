# Keil uVision project PW.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PW +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32_F10X_HD
  c include: ..\Basis_Lib;..\Devices;..\STM32_Driver;..\STM32_Lib\CMSIS\CM3\CoreSupport;..\STM32_Lib\STM32F10x_StdPeriph_Driver\inc;..\STM32_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../User/: User.h main.c LiBAT.c LiBAT.h GetSensor.c GetSensor.h ParamAccess.c ParamAccess.h SystemState.h Test.h Test.c
  group Devices
    ../Devices/: Devices.h ADS8341.c ADS8341.h BQ76925.c BQ76925.h LED.c LED.h
  group Basis_Lib
    ../Basis_Lib/: Memory.c Queue.c Memory.h Queue.h Function.c Function.h
  group STM32_Driver
    ../STM32_Driver/: CAN.c CAN1.c CAN2.c Flash.c I2C1.c ISRHandler.c PortPin.c SPI.c SPI1.c stm32f10x_it.c SysTick.c TIM2.c TIM3.c TIM4.c UART.c UART1.c UART2.c UART3.c UART4.c I2C.c
  group CMSIS
    ../STM32_Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32_Lib
    ../STM32_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c
  group START_UP
    ../STM32_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
